## config/boards/shields/reviung34split/Kconfig.defconfig
```kconfig
if SHIELD_reviung34split

config ZMK_KEYBOARD_NAME
    default "reviung34split"

endif
```
